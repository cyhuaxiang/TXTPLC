# Keil uVision project project.uvprojx, settings and files
target Flash (ARM-ADS)
  device: NUC029LAN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.2.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: output +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\Device\Nuvoton\NUC029xAN\Include;..\..\Libraries\StdDriver\inc;..\..\User\app\inc;..\..\User\bsp\inc;..\..\User\bsp;..\..\User\fonts
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group App
    ../../User/app/src/: main.c param.c gui.c main_run.c system_set.c
  group BSP
    ../../User/bsp/: bsp.c
    ../../User/bsp/src/: bsp_timer.c bsp_key.c bsp_lcd.c bsp_mtx_key.c bsp_cpu_flash.c bsp_relay595.c bsp_uart_fifo.c
  group MDK-ARM
    ../../Libraries/Device/Nuvoton/NUC029xAN/Source/ARM/: startup_NUC029xAN.s
  group StdPeriph_Driver
    ../../Libraries/StdDriver/src/: clk.c gpio.c sys.c timer.c uart.c retarget.c fmc.c
  group CMSIS
    ../../Libraries/Device/Nuvoton/NUC029xAN/Source/: system_NUC029xAN.c
  group Fonts
    ../../User/fonts/: asc12.c asc16.c hz12.c hz16.c hz24.c hz32.c
